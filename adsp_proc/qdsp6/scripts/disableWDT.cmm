PER.S AD:0x28882024 %LONG 0
